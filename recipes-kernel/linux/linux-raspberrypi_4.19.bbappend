LINUX_VERSION = "4.19.73"

SRCREV = "4d486c17f636bb339c10cd73a07292220a973e01"

KERNEL_DEVICETREE = " \
    ${RPI_KERNEL_DEVICETREE} \
    ${RPI_KERNEL_DEVICETREE_OVERLAYS} \
"
